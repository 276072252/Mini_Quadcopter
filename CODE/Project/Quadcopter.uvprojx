# Keil uVision project Quadcopter.uvprojx, settings and files
target Quadcopter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Quadcopter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DEBUG_ENABLE_SEMIHOST
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\DRIVER\inc;..\COMMUNICATE;..\CONTROL;..\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../USER/: main.c
  group DRIVER
    ../DRIVER/src/: delay.c exit.c fbm320.c flash.c iic.c led.c motor.c mpu6050.c nvic.c power.c si24r1.c spi.c system.c tim.c usart.c
  group COMMUNICATE
    ../COMMUNICATE/: ANO_DT.c remotedata.c
  group CONTROL
    ../CONTROL/: altitude.c altitude_estimator.c control.c paramsave.c pid.c
  group IMU
    ../IMU/: filter.c imu.c
